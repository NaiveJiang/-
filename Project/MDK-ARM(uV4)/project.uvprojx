# Keil uVision project project.uvprojx, settings and files
target FreeRTOS_STM32F1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\User\User_App;..\..\User\User_Driver;..\..\User\Font_And_Bmp;..\..\User\User_GUI;..\..\User\Util;..\..\User\ISP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../../User/: main.c includes.h FreeRTOSConfig.h
  group User_GUI
    ../../User/User_GUI/: gui_data.c gui_main.c gui_powSet.c
  group User_App
    ../../User/User_App/: app.h parameters.h app.c app_adc.c app_discharge.c app_dry.c app_input.c app_filter.c app_findfire.c app_flash.c app_mcrc16.c app_serial.c app_supervisor.c app_ntc.c app_roll_changing.c
  group User_Driver
    ../../User/User_Driver/: driver.h driver.c driver_can.c driver_dac.c driver_key.c driver_gui.c driver_linearMovement.c driver_pulsecap.c driver_wdg.c driver_485.c driver_swport.c driver_roll_changing.c
  group ISP
    ../../User/ISP/: isp_can.c isp_usart.c isp_rtc.c isp_tim.c isp_exti.c
  group BSP
    ../../User/bsp/: bsp.h BSP_DMA_DEFINE.h bsp.c bsp_cpu_flash.c BSP_IIC_SW.c BSP_GPIO.c BSP_EXTI.c BSP_Timer.c BSP_CAN.c BSP_USART.c BSP_RTC.c BSP_BKP_PWR.c
    ../../User/bsp/src/: bsp_led.c bsp_uart_fifo.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_dac.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
    ../../User/bsp/: stm32f10x_assert.c stm32f10x_it.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt
  group Font_And_Bmp
    ../../User/Font_And_Bmp/: oled_bmp.h oled_font.h
  group UTIL
    ../../User/Util/: util.c
software components: CMSIS:CORE 5.4.0
